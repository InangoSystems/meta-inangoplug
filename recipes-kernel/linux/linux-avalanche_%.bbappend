FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
        file://adding_am_id_to_session_info_ARM.patch \
"
