FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_puma7 = " \
        file://0001-am-callbacks-installation.patch \
"
