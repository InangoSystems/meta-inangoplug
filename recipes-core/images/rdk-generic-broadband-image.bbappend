IMAGE_INSTALL_append_puma7 = " \
    packagegroup-inangoplug \
"
