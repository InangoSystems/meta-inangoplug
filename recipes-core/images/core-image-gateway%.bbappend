IMAGE_INSTALL_append_puma7arm = " \
    packagegroup-inangoplug \
"
